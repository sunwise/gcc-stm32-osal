# IAR project Project.ewp, settings and files
configuration GD32F130_150 (ARM, debug)
  General.OGChipSelectEditMenu: GD32F150x8 GD GD32F150x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F130_150
  ICCARM.CCIncludePath2: ..\..\Firmware; ..\..\Firmware\CMSIS\GD\GD32F1x0; ..\..\Firmware\CMSIS\GD\GD32F1x0\Include; ..\..\Firmware\CMSIS; ..; ..\..\Utilities; ..\..\Firmware\GD32F1x0_standard_peripheral\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F150x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32F170_190 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F190x8 GD GD32F190x8
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F170_190
  ICCARM.CCIncludePath2: ..\..\Firmware; ..\..\Firmware\CMSIS\GD\GD32F1x0; ..\..\Firmware\CMSIS\GD\GD32F1x0\Include; ..\..\Firmware\CMSIS; ..; $TOOLKIT_DIR$\..\..\..\..\Keil_v5\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include; ..\..\Utilities; ..\..\Firmware\GD32F1x0_standard_peripheral\Include
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F190x8.icf
  group Application
    ../: gd32f1x0_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F1x0/Source/IAR/: startup_gd32f1x0.s
    ../../Firmware/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group Doc
    ../: readme.txt
  group Peripherals
    ../../Firmware/GD32F1x0_standard_peripheral/Source/: gd32f1x0_adc.c gd32f1x0_can.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_ivref.c gd32f1x0_misc.c gd32f1x0_opa.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_slcd.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group Utilities
    ../../Utilities/: gd32f1x0_eval.c
