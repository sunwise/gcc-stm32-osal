# IAR project RemoteGD32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F130x8 GD GD32F130x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F130_150
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/GD32F1x0_standard_peripheral/Include; ../Drivers/CMSIS/GD/GD32F1x0/Include; ../Drivers/CMSIS; ..\OSAL\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application/EWARM
    ../Drivers/CMSIS/GD/GD32F1x0/Source/IAR/: startup_gd32f1x0.s
  group Application/User/Core
    ../Core/Src/: gd32f1x0_it.c main.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group Drivers/GD32F1x0_standard_peripheral
    ../Drivers/GD32F1x0_standard_peripheral/Source/: gd32f1x0_adc.c gd32f1x0_can.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_ivref.c gd32f1x0_misc.c gd32f1x0_opa.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_slcd.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group OSAL/hal
    ../OSAL/hal/: timer.c
  group OSAL/osal
    ../OSAL/osal/: osal.c osal_event.c osal_memory.c osal_msg.c osal_timer.c
