<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32_CUBEMX.ewp</path>
  </project>
  <batchBuild />
</workspace>
